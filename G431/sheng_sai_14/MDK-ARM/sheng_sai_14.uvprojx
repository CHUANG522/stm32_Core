# Keil uVision project sheng_sai_14.uvprojx, settings and files
target sheng_sai_14 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32G431R8Tx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.2.0.0
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0x8000000-0x801FFFF)  CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: sheng_sai_14 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32G431xx
  c include: ../Core/Inc;../Drivers/STM32G4xx_HAL_Driver/Inc;../Drivers/STM32G4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32G4xx/Include;../Drivers/CMSIS/Include;../Mycode
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application/MDK-ARM
    ./: startup_stm32g431xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c tim.c stm32g4xx_it.c stm32g4xx_hal_msp.c
  group Drivers/STM32G4xx_HAL_Driver
    ../Drivers/STM32G4xx_HAL_Driver/Src/: stm32g4xx_hal_adc.c stm32g4xx_hal_adc_ex.c stm32g4xx_ll_adc.c stm32g4xx_hal.c stm32g4xx_hal_rcc.c stm32g4xx_hal_rcc_ex.c stm32g4xx_hal_flash.c stm32g4xx_hal_flash_ex.c stm32g4xx_hal_flash_ramfunc.c stm32g4xx_hal_gpio.c stm32g4xx_hal_exti.c stm32g4xx_hal_dma.c stm32g4xx_hal_dma_ex.c stm32g4xx_hal_pwr.c stm32g4xx_hal_pwr_ex.c stm32g4xx_hal_cortex.c stm32g4xx_hal_tim.c stm32g4xx_hal_tim_ex.c
  group Drivers/CMSIS
    ../Drivers/STM32G4xx_HAL_Driver/Inc/: stm32_assert_template.h stm32g4xx_hal.h stm32g4xx_hal_adc.h stm32g4xx_hal_adc_ex.h stm32g4xx_hal_comp.h stm32g4xx_hal_conf_template.h stm32g4xx_hal_cordic.h stm32g4xx_hal_cortex.h stm32g4xx_hal_crc.h stm32g4xx_hal_crc_ex.h stm32g4xx_hal_cryp.h stm32g4xx_hal_cryp_ex.h stm32g4xx_hal_dac.h stm32g4xx_hal_dac_ex.h stm32g4xx_hal_def.h stm32g4xx_hal_dma.h stm32g4xx_hal_dma_ex.h stm32g4xx_hal_exti.h stm32g4xx_hal_fdcan.h stm32g4xx_hal_flash.h stm32g4xx_hal_flash_ex.h stm32g4xx_hal_flash_ramfunc.h stm32g4xx_hal_fmac.h stm32g4xx_hal_gpio.h stm32g4xx_hal_gpio_ex.h stm32g4xx_hal_hrtim.h stm32g4xx_hal_i2c.h stm32g4xx_hal_i2c_ex.h stm32g4xx_hal_i2s.h stm32g4xx_hal_irda.h stm32g4xx_hal_irda_ex.h stm32g4xx_hal_iwdg.h stm32g4xx_hal_lptim.h stm32g4xx_hal_nand.h stm32g4xx_hal_nor.h stm32g4xx_hal_opamp.h stm32g4xx_hal_opamp_ex.h stm32g4xx_hal_pcd.h stm32g4xx_hal_pcd_ex.h stm32g4xx_hal_pwr.h stm32g4xx_hal_pwr_ex.h stm32g4xx_hal_qspi.h stm32g4xx_hal_rcc.h stm32g4xx_hal_rcc_ex.h stm32g4xx_hal_rng.h stm32g4xx_hal_rtc.h stm32g4xx_hal_rtc_ex.h stm32g4xx_hal_sai.h stm32g4xx_hal_sai_ex.h stm32g4xx_hal_smartcard.h stm32g4xx_hal_smartcard_ex.h stm32g4xx_hal_smbus.h stm32g4xx_hal_smbus_ex.h stm32g4xx_hal_spi.h stm32g4xx_hal_spi_ex.h stm32g4xx_hal_sram.h stm32g4xx_hal_tim.h stm32g4xx_hal_tim_ex.h stm32g4xx_hal_uart.h stm32g4xx_hal_uart_ex.h stm32g4xx_hal_usart.h stm32g4xx_hal_usart_ex.h stm32g4xx_hal_wwdg.h stm32g4xx_ll_adc.h stm32g4xx_ll_bus.h stm32g4xx_ll_comp.h stm32g4xx_ll_cordic.h stm32g4xx_ll_cortex.h stm32g4xx_ll_crc.h stm32g4xx_ll_crs.h stm32g4xx_ll_dac.h stm32g4xx_ll_dma.h stm32g4xx_ll_dmamux.h stm32g4xx_ll_exti.h stm32g4xx_ll_fmac.h stm32g4xx_ll_fmc.h stm32g4xx_ll_gpio.h stm32g4xx_ll_hrtim.h stm32g4xx_ll_i2c.h stm32g4xx_ll_iwdg.h stm32g4xx_ll_lptim.h stm32g4xx_ll_lpuart.h stm32g4xx_ll_opamp.h stm32g4xx_ll_pwr.h stm32g4xx_ll_rcc.h stm32g4xx_ll_rng.h stm32g4xx_ll_rtc.h stm32g4xx_ll_spi.h stm32g4xx_ll_system.h stm32g4xx_ll_tim.h stm32g4xx_ll_ucpd.h stm32g4xx_ll_usart.h stm32g4xx_ll_usb.h stm32g4xx_ll_utils.h stm32g4xx_ll_wwdg.h
    ../Core/Src/: system_stm32g4xx.c
  group MyCode
    ../Mycode/: fun.c fun.h Header.h fonts.h lcd.c lcd.h
software components: CMSIS:CORE 4.3.0
